# Keil uVision project trafficlight.uvproj, settings and files
target PROJECT (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: trafficlight +hex
  c flags: Optimize=8 SizeSpeed=1
  group TrafficLight
    ./: STARTUP.A51 TrafficLight.c
